# Keil uVision project 3GIOT.uvproj, settings and files
target 3GIOT (ARM-ADS)
  device: STM32F103CB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: 3GIOT +hex
  c flags: Optim=1 OneElfS=1
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group user
    ../src/: main.c NVIC.c publicFuc.c RCC.c stm32f10x_it.c publicFuc.h include.h main.h mytype.h
  group startup
    ../src/STM32Lib/StartUp/: startup_stm32f10x_md.s
  group stm32lib
    ../src/STM32Lib/: core_cm3.c misc.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c system_stm32f10x.c stm32f10x_tim.c stm32f10x_can.c
  group ucosii
    ../src/UCOSII/: os_core.c os_cpu_c.c os_dbg.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c os_cpu_a.asm
  group timer
    ../src/timer/: timer.c
  group zigbee
    ../src/zigbee/: zigbee.c
  group com
    ../src/com/: com.c
  group leds
    ../src/Leds/: Leds.c
  group key
    ../src/Key/: Key.c
  group bsp
    ../src/bsp/: bsp.c
  group can
    ../src/can/: can.c
  group crc8_16
    ../src/crc8_16/: crc8_16.c
  group protocol
    ../src/protocol/: zjy_pro.c zjy_pro.h syf_pro.c syf_pro.h protocol.c protocol.h
  group malloc
    ../src/malloc/: malloc.c
